# Keil uVision project GatewayBootloader.uvprojx, settings and files
target GatewayBootloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x8005FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bootloader +hex
  AfterMake: fromelf --bin --output .\Bootloader\bootloader.bin .\Bootloader\bootloader.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..;../../app/Core/Inc;../../app/User/App;../../app/Drivers/STM32F1xx_HAL_Driver/Inc;../../app/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../../app/Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../app/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Bootloader
    ../: main.c ota_board.c system_stm32f1xx.c
  group OTA/Common
    ../../app/User/App/: ota_hash.c ota_w25.c ota_meta.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../app/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c
software components: CMSIS:CORE 4.3.0
