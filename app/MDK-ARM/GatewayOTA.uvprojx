# Keil uVision project GatewayOTA.uvprojx, settings and files
target GatewayOTA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8006000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GatewayOTA +hex
  AfterMake: fromelf --bin --output .\GatewayOTA\GatewayOTA.bin .\GatewayOTA\GatewayOTA.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,GW_APP_VERSION=10204
  c include: ../Core/Inc;../FreeRTOS/RVDS;../FreeRTOS/Inc;../User;../User/BSP;../User/App;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8006000 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group User/BSP
    ../User/BSP/: OLED.c
  group User/App
    ../User/App/: gateway_protocol.c flash_queue.c modbus_master.c ota_w25.c ota_hash.c ota_download.c ota_meta.c
  group FreeRTOS/Kernel
    ../FreeRTOS/Src/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/RVDS/: port.c
software components: CMSIS:CORE 4.3.0
